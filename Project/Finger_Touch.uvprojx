# Keil uVision project Finger_Touch.uvprojx, settings and files
target FINGER_TOUCH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f10x_fwlib_template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS;..\User;..\User\Drivers\Delay;..\User\Drivers\GPIO;..\User\Drivers\NVIC;..\User\Drivers\TIM;..\User\Drivers\USART;..\User\Drivers\DMA;..\User\Devices\AS608;..\User\Devices\bsp_key
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: loop.c stm32f10x_it.c user.c
  group DOC
    ../Doc/: readme.txt
  group DEVICES
    ../User/Devices/bsp_Key/: bsp_key.c
    ../User/Devices/AS608/: as608.c
  group DRIVERS
    ../User/Drivers/Delay/: delay.c
    ../User/Drivers/GPIO/: GPIO.c
    ../User/Drivers/NVIC/: NVIC.C
    ../User/Drivers/TIM/: TIM.c
    ../User/Drivers/SysTick/: SysTick.c
    ../User/Drivers/USART/: USART.c
    ../User/Drivers/DMA/: DMA.c
  group APP
    ../User/Devices/AS608/: FingerPrint.c
